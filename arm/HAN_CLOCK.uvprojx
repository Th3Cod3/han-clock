# Keil uVision project HAN_CLOCK.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: StepperTest
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement -Wno-unsafe-buffer-usage
  c include: .\src;.\firmwares\stepper;.\firmwares\uart0;.\firmwares\queue
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./src/: main.c
  group firmwares/stepper
    ./firmwares/stepper/: stepper.c stepper.h
  group firmwares/queue
    ./firmwares/queue/: queue.c queue.h
  group firmwares/uart0
    ./firmwares/uart0/: uart0.c uart0.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
